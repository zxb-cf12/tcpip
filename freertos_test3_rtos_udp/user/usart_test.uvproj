# Keil uVision project usart_test.uvproj, settings and files
target usart_test (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: usart_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\core;..\lib\inc;..\myc\app;..\myc\hd;..\user;..\freertos\include;..\freertos;..\freertos\MemMang;..\lwip-1.4.1\include;..\lwip-1.4.1\include\ipv4;..\lwip-1.4.1;..\lwip-1.4.1\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../myc/app/: app_config.c delay.c led_flash.c
  group HARDWARE
    ../myc/hd/: led.c UsartHandle.c ethernetif.c ethernet_phyconfig.c UserUdp.c
  group CORE
    ../core/: core_cm3.c startup_stm32f10x_cl.s
  group SOURCE
    ../lib/src/: misc.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_dma.c stm32f4x7_eth.c
  group FreeRTOS
    ../freertos/: croutine.c list.c port.c queue.c tasks.c timers.c FreeRTOSConfig.h
    ../freertos/MemMang/: heap_4.c
  group Lwip/api
    ../lwip-1.4.1/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/core
    ../lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Lwip/netif
    ../lwip-1.4.1/netif/: etharp.c
  group Lwip/arch
    ../lwip-1.4.1/arch/: sys_arch.c
